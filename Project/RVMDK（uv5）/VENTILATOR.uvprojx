# Keil uVision project VENTILATOR.uvprojx, settings and files
target VENTILATOR (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: VENTILATOR +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\rtthread\3.0.3\components\finsh;..\..\rtthread\3.0.3\include;..\..\rtthread\3.0.3\include\libc;..\..\User;..\..\User\Bsp\led;..\..\User\Bsp\key;..\..\User\Bsp\uart;..\..\User\Bsp;..\..\User\Bsp\SPD810;..\..\User\Bsp\i2c;..\..\User\Bsp\SDP8XX;..\..\User\Bsp\led;..\..\User\Bsp\air_blower;..\..\User\Bsp\xgzp6859;..\..\User\Bsp\siic;..\..\App;..\..\App\Ventilator_function;..\..\User\Bsp\humidification;..\..\User\Bsp\flash;..\..\User\Bsp\lcd;..\..\User\Bsp\wkup;..\..\User\Bsp\BUZZER;..\..\User\Bsp\SHT20;..\..\User\Bsp\btim;..\..\User\Bsp\RTC;..\..\User\Bsp\ds18b20;..\..\rtthread\3.0.3\components\drivers\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USER
    ../../User/: main.c stm32f4xx_it.c board.c rtconfig.h
    ../../User/Bsp/uart/: bsp_debug_usart.c
    ../../User/Bsp/SDP8XX/: SDP8XX.c
    ../../User/Bsp/air_blower/: air_blower.c
    ../../User/Bsp/xgzp6859/: xgzp6859.c
    ../../User/Bsp/siic/: siic.c
    ../../User/Bsp/key/: key.c
    ../../User/Bsp/humidification/: humidification.c
    ../../User/Bsp/lcd/: lcd_init.c lcd.c
    ../../User/Bsp/led/: led.c
    ../../User/Bsp/flash/: myflash.c
    ../../User/Bsp/wkup/: wkup.c
    ../../User/Bsp/BUZZER/: buzzer.c
    ../../User/Bsp/SHT20/: sht20.c
    ../../User/Bsp/btim/: btim.c
    ../../User/Bsp/RTC/: rtc.c
    ../../User/Bsp/ds18b20/: ds18b20.c
  group DOC
    ../../: 必读说明.txt
  group rtt/source
    ../../rtthread/3.0.3/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group rtt/ports
    ../../rtthread/3.0.3/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group APP
    ../../App/Ventilator_function/: Ventilator_function.c
  group decive
    ../../rtthread/3.0.3/components/drivers/serial/: serial.c
